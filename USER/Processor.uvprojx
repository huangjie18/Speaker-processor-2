# Keil uVision project Processor.uvprojx, settings and files
target Processor (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Processor +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_StdPeriph_Driver\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LCD;..\STemWin\Config;..\STemWin\inc;..\MALLOC;..\HARDWARE\TIMER;..\STemWin\Demo;..\HARDWARE\Test;..\HARDWARE\InterFace;..\HARDWARE\LED;..\HARDWARE\KEY;..\STemWin\STemWin_Addons;..\HARDWARE\TOUCH
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_tim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/Test/: test.c example.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/Lannge/: lannge_yellow.c lannge_white.c
    ../HARDWARE/TOUCH/: touch.c
  group STemWin_Config
    ../STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c GUI_X_Touch_Analog.c
    ../STemWin/OS/: GUI_X.c
  group STemWin_LIB
    ../STemWin/Lib/: GUI_CM3_L.lib
  group malloc
    ../MALLOC/: malloc.c
  group Interface
    ../HARDWARE/InterFace/: Main_face.c Flex_set.c Input_face.c Input1_third_layer.c
    ../HARDWARE/InterFace/ChildWindow/: First_ChildDLG.c Second_ChildDLG.c Third_ChildDLG.c Four_ChildDLG.c Five_ChildDLG.c
  group Interface_Out
    ../HARDWARE/InterFace_Out/: Out_face.c Output1_third_face.c
    ../HARDWARE/InterFace_Out/Window_Child/: Out-Firstchild.c
  group Interface_Coax
    ../HARDWARE/InterFacd-Coax/: Coax_face.c COAX_face_3DLG.c
  group Interface_Gen
    ../HARDWARE/Interface_Gen/: Gen_OutDLG.c Gen_WNoiseDLG.c Gen_SinDLG.c Gen_SweepDLG.c Sweep_child_1DLG.c Gen_PulseDLG.c Pulse_ChildDLG.c WNoise_Child1DLG.c Gen_WNoise2DLG.c WNoise_Child2DLG.c
    ../HARDWARE/Interface_Gen/Child/: Sweep_TwoDLG.c SIN_Child1DLG.c
  group Interface_Sys
    ../HARDWARE/InterFace_Sys/: SystemDLG.c
  group Interface_Mode
    ../HARDWARE/InterFace_Mode/: ModeDLG.c
  group example
    ../HARDWARE/example/: MOTION_RadialMenu.c
